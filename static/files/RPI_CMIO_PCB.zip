# Allegro board RPI-CMIO-V3_0-PUBLIC_allegro16.6.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CD1_SCL: length 126.1
  TOP w0.15: J12.20 5.72,92.25 6.8,93.33 R16.2
  TOP w0.2: J11.20 v1(4.15,39.25) ; J12.20 v1(4.12,92.25)
  PWRB w0.2: v1(6.6,42.6) 5.7,43.5 5.7,62.9 5.3,63.3 5.3,91.07 v1(4.12,92.25) ; v1(4.15,39.25) 13.75,39.25 20.7,46.2 22.2,46.2 23.4,47.4 62.7,47.4 J6.39
  BOTTOM w0.2: v1(4.15,39.25) 4.15,40.65 6.1,42.6 v1(6.6,42.6)
CD1_SDA: length 125.7
  TOP w0.15: J12.21 5.72,92.75 5.96,92.98 5.96,93.45 5.7,93.7 R17.2
  TOP w0.2: v1(3.55,92.75) J12.21 ; J11.21 v1(3.4,39.75)
  PWRB w0.2: J6.37 64.74,47.9 20.9,47.9 12.75,39.75 v1(3.4,39.75) 3.4,40.9 5.15,42.65 5.15,62.75 4.8,63.1 4.8,90.5 3.55,91.75 v1(3.55,92.75)
CEC: length 6.9
  TOP w0.2: Q3.3 12.73,54.5 12.5,54.73 ; U4.A2 12.5,54.73 ; 12.5,54.73 11.77,54 J13.13 v1(8.06,54)
CM_1V8: length 12.2
  TOP w0.3: v1(24.28,31.95) J1.183 20.93,31.95 20.88,32 C10.1 20.65,31.35 v1(21.52,31.35) J1.185 ; J1.184 v1(29.72,31.65) ; J1.186 v1(32.48,31.05)
  TOP w0.5: v1(39,21.85) R5.2 v1(37.9,20.95)
CM_3V3: length 11.3
  TOP w0.3: v1(24.28,29.55) J1.191 20.93,29.55 20.88,29.5 20.97,29.5 v1(21.52,28.95) J1.193 ; J1.194 v1(32.48,28.65) ; J1.192 v1(29.72,29.25)
  TOP w0.5: C3.1 20.88,29.5 ; v1(35.1,20.95) R4.2 v1(34,21.85)
CM_VBAT: length 12
  TOP w0.3: C1.1 20.35,27 ; 20.35,27 21.1,27.75 v1(21.52,27.75) J1.197 ; 20.35,27 21.25,27 21.4,27.15 J1.199 v1(24.28,27.15) ; J1.200 v1(29.72,26.85) ; J1.198 v1(32.48,27.45)
  TOP w0.5: v1(30.4,20.95) R1.2 v1(31.5,21.85)
CM_VDAC: length 25.2
  TOP w0.3: J1.189 v1(21.52,30.15) ; J1.190 v1(32.48,29.85)
  TOP w0.5: R6.2 v1(36.5,21.85)
  PWRB w0.3: v1(21.52,30.15) 24.85,30.15 25.15,29.85 v1(32.48,29.85)
  PWRB w0.5: v1(36.5,21.85) 36.5,27.2 33.85,29.85 v1(32.48,29.85)
DAC_2V5: length 12.7
  TOP w0.3: U2.5 42.1,14.7 C5.1 v1(42.65,15)
  TOP w0.5: C5.1 41.8,15.88 41.08,16.6 37.7,16.6 36.5,17.8 R6.1
  BOTTOM w0.5: PP4.1 43.2,15 v1(42.65,15)
DSI0_CN: length 32.3
  TOP w0.116: v1(18.16,60.49) 17.74,60.49 17.3,60.05 17.3,56 18.12,55.18 19.15,55.18 19.27,55.3 19.63,55.3 19.75,55.18 19.95,55.18 20.15,55.38 20.35,55.38 20.55,55.18 20.75,55.18 20.95,55.38 21.15,55.38 21.35,55.18 21.55,55.18 21.73,55.35 J1.105 ; v1(3.06,68.08) 3.35,68.37 3.8,68.37 4.2,68.37 4.33,68.25 J10.8
  BOTTOM w0.116: v1(18.16,60.49) 17.74,60.49 17.59,60.34 17.01,60.34 8.97,68.37 3.35,68.37 v1(3.06,68.08)
DSI0_CP: length 32.3
  TOP w0.116: J1.107 21.73,54.75 21.55,54.92 18.02,54.92 17.05,55.9 17.05,60.16 17.56,60.67 v1(17.56,61.09) ; J10.9 4.33,68.75 4.2,68.63 3.7,68.63 3.35,68.63 v1(3.06,68.92)
  BOTTOM w0.116: v1(17.56,61.09) 17.56,60.67 17.48,60.59 17.11,60.59 9.07,68.63 3.35,68.63 v1(3.06,68.92)
DSI0_DN0: length 32.3
  TOP w0.116: J1.99 21.73,57.15 21.55,56.98 21.19,56.98 21.08,57.09 21.08,57.23 20.96,57.35 20.73,57.35 20.61,57.23 20.61,57.09 20.5,56.98 20.26,56.98 20.15,57.09 20.15,57.18 20.03,57.3 19.8,57.3 19.68,57.18 19.68,57.09 19.57,56.98 19.1,56.98 v1(18.8,57.27) ; v1(3.36,65.08) 3.65,65.37 4.2,65.37 4.33,65.25 J10.2
  BOTTOM w0.116: v1(3.36,65.08) 3.06,65.37 2.48,65.37 2,64.9 2,63.55 3.4,62.15 3.77,62.15 4.03,61.89 4.03,61.37 4.14,61.25 4.38,61.25 4.49,61.37 4.49,61.89 4.76,62.15 5.2,62.15 5.46,61.89 5.46,61.37 5.57,61.25 5.81,61.25 5.92,61.37 5.92,61.89 6.19,62.15 11.15,62.15 16.33,56.98 18.5,56.98 v1(18.8,57.27)
DSI0_DN1: length 32
  TOP w0.116: v1(6.72,64.08) 7.13,64.08 8.1,65.05 8.1,65.55 6.78,66.87 5.8,66.87 5.67,66.75 J10.5 ; v1(18.8,59.07) 19.1,58.78 19.95,58.78 20.15,58.98 20.35,58.98 20.55,58.78 20.75,58.78 20.95,58.98 21.15,58.98 21.35,58.78 21.55,58.78 21.73,58.95 J1.93
  BOTTOM w0.116: v1(6.72,64.08) 7.13,64.08 8.5,65.45 9.5,65.45 10.13,64.83 10.29,64.83 10.7,65.23 11.07,65.23 11.38,64.92 11.38,64.55 10.97,64.15 10.97,63.98 11.14,63.82 11.3,63.82 11.71,64.22 12.08,64.22 12.39,63.91 12.39,63.54 11.99,63.13 11.99,62.97 12.15,62.81 12.31,62.81 12.72,63.21 13.09,63.21 13.4,62.9 13.4,62.53 13,62.12 13,61.96 13.16,61.79 13.32,61.79 13.73,62.2 14.1,62.2 14.41,61.89 14.41,61.52 14.01,61.11 14.01,60.95 16.18,58.78 18.5,58.78 v1(18.8,59.07)
DSI0_DP0: length 32.3
  TOP w0.116: v1(18.8,56.43) 19.1,56.72 21.55,56.72 21.73,56.55 J1.101 ; v1(3.36,65.92) 3.65,65.63 4.2,65.63 4.33,65.75 J10.3
  BOTTOM w0.116: v1(3.36,65.92) 3.06,65.63 2.38,65.63 1.75,65 1.75,63.45 3.3,61.9 3.66,61.9 3.78,61.78 3.78,61.26 4.04,61 4.48,61 4.74,61.26 4.74,61.78 4.86,61.9 5.09,61.9 5.21,61.78 5.21,61.26 5.47,61 5.91,61 6.17,61.26 6.17,61.78 6.29,61.9 11.05,61.9 16.23,56.72 18.5,56.72 v1(18.8,56.43)
DSI0_DP1: length 32.1
  TOP w0.116: J10.6 5.67,67.25 5.8,67.13 6.88,67.13 8.35,65.65 8.35,64.95 7.31,63.91 v1(7.31,63.49) ; J1.95 21.73,58.35 21.55,58.52 19.1,58.52 v1(18.8,58.23)
  BOTTOM w0.116: v1(7.31,63.49) 7.31,63.91 8.6,65.2 9.4,65.2 10.02,64.58 10.39,64.58 10.8,64.98 10.96,64.98 11.13,64.82 11.13,64.65 10.72,64.25 10.72,63.88 11.03,63.57 11.41,63.57 11.81,63.97 11.97,63.97 12.14,63.81 12.14,63.64 11.73,63.24 11.73,62.87 12.05,62.55 12.42,62.55 12.82,62.96 12.99,62.96 13.15,62.79 13.15,62.63 12.75,62.23 12.75,61.85 13.06,61.54 13.43,61.54 13.83,61.95 14,61.95 14.16,61.78 14.16,61.62 13.76,61.21 13.76,60.84 16.08,58.52 18.5,58.52 v1(18.8,58.23)
DSI1_CN: length 55.1
  TOP w0.115: J1.102 32.25,56.25 32.44,56.43 33.28,56.43 v1(33.56,56.15)
  TOP w0.116: v1(12.85,86.08) 12.55,86.37 5.8,86.37 5.67,86.25 J12.8
  BOTTOM w0.116: v1(33.56,56.15) 33.14,56.15 32.87,56.42 29.48,56.42 21.95,63.95 20.95,63.95 13.9,71 13.9,82.18 13.78,82.29 13.36,82.29 13.1,82.56 13.1,83 13.36,83.26 13.78,83.26 13.9,83.38 13.9,83.61 13.78,83.72 13.36,83.72 13.1,83.99 13.1,84.43 13.36,84.69 13.78,84.69 13.9,84.81 13.9,85.95 13.48,86.37 13.15,86.37 v1(12.85,86.08)
DSI1_CP: length 55.1
  TOP w0.115: J1.100 32.25,56.85 32.44,56.66 33.28,56.66 v1(33.56,56.94)
  TOP w0.116: v1(12.85,86.92) 12.55,86.63 5.8,86.63 5.67,86.75 J12.9
  BOTTOM w0.116: v1(12.85,86.92) 13.14,86.63 13.58,86.63 14.15,86.05 14.15,84.7 13.89,84.44 13.47,84.44 13.35,84.32 13.35,84.09 13.47,83.98 13.89,83.98 14.15,83.71 14.15,83.27 13.89,83.01 13.47,83.01 13.35,82.89 13.35,82.66 13.47,82.55 13.89,82.55 14.15,82.28 14.15,71.1 21.05,64.2 22.05,64.2 29.58,56.67 32.87,56.67 33.14,56.94 v1(33.56,56.94)
DSI1_DN0: length 54.9
  TOP w0.115: J1.96 32.25,58.05 32.44,58.24 33.28,58.24 v1(33.56,57.96)
  TOP w0.116: v1(15.2,83.08) 14.9,83.37 5.8,83.37 5.67,83.25 J12.2
  BOTTOM w0.116: v1(33.56,57.96) 33.14,57.96 32.87,58.22 29.53,58.22 21.95,65.8 21,65.8 16.75,70.05 16.75,77 16.63,77.12 15.86,77.12 15.6,77.38 15.6,77.82 15.86,78.09 16.63,78.09 16.75,78.2 16.75,78.43 16.63,78.55 15.86,78.55 15.6,78.81 15.6,79.25 15.86,79.52 16.63,79.52 16.75,79.63 16.75,79.86 16.63,79.98 15.86,79.98 15.6,80.24 15.6,80.68 15.86,80.95 16.63,80.95 16.75,81.06 16.75,82.55 15.93,83.37 15.5,83.37 v1(15.2,83.08)
DSI1_DN1: length 55.2
  TOP w0.115: v1(33.56,50.76) 33.28,51.04 32.44,51.04 32.25,50.85 J1.120
  TOP w0.116: J12.5 5.67,84.75 5.8,84.87 6.22,84.87 6.67,84.87 v1(6.97,84.58)
  BOTTOM w0.116: v1(6.97,84.58) 7.26,84.87 8.22,84.87 9.25,83.85 9.25,82.7 9.13,82.59 8.86,82.59 8.6,82.32 8.6,81.88 8.86,81.62 9.13,81.62 9.25,81.51 9.25,81.27 9.13,81.16 8.86,81.16 8.6,80.89 8.6,80.45 8.86,80.19 9.13,80.19 9.25,80.08 9.25,70.5 21.15,58.6 21.95,58.6 29.52,51.02 32.87,51.02 33.14,50.76 v1(33.56,50.76)
DSI1_DN2: length 55
  TOP w0.115: v1(33.56,52.55) 33.28,52.83 32.44,52.83 32.25,52.65 J1.114
  TOP w0.116: J12.11 5.67,87.75 5.8,87.87 6.67,87.87 v1(6.97,87.58)
  BOTTOM w0.116: v1(33.56,52.55) 33.14,52.55 32.87,52.82 29.63,52.82 22.1,60.35 21.1,60.35 10.45,71 10.45,86.15 8.73,87.87 7.26,87.87 v1(6.97,87.58)
DSI1_DN3: length 55
  TOP w0.115: v1(33.56,54.36) 33.28,54.63 32.44,54.63 32.25,54.45 J1.108
  TOP w0.116: v1(6.61,89.12) 6.36,89.37 5.8,89.37 5.67,89.25 J12.14
  BOTTOM w0.116: v1(33.56,54.36) 33.14,54.36 32.87,54.62 29.57,54.62 21.95,62.25 20.65,62.25 11.65,71.24 11.65,86.6 8.87,89.37 6.86,89.37 v1(6.61,89.12)
DSI1_DP0: length 54.9
  TOP w0.115: J1.94 32.25,58.65 32.44,58.47 33.28,58.47 v1(33.56,58.74)
  TOP w0.116: J12.3 5.67,83.75 5.8,83.63 14.9,83.63 v1(15.2,83.92)
  BOTTOM w0.116: v1(15.2,83.92) 15.5,83.63 16.03,83.63 17,82.65 17,80.96 16.74,80.69 15.97,80.69 15.85,80.58 15.85,80.35 15.97,80.23 16.74,80.23 17,79.97 17,79.53 16.74,79.26 15.97,79.26 15.85,79.15 15.85,78.92 15.97,78.8 16.74,78.8 17,78.54 17,78.1 16.74,77.83 15.97,77.83 15.85,77.72 15.85,77.49 15.97,77.37 16.74,77.37 17,77.11 17,70.15 21.1,66.05 22.05,66.05 29.63,58.48 32.87,58.48 33.14,58.74 v1(33.56,58.74)
DSI1_DP1: length 55.2
  TOP w0.115: v1(33.56,51.54) 33.28,51.26 32.44,51.26 32.25,51.45 J1.118
  TOP w0.116: v1(6.97,85.42) 6.67,85.13 6.32,85.13 5.8,85.13 5.67,85.25 J12.6
  BOTTOM w0.116: v1(33.56,51.54) 33.14,51.54 32.87,51.28 29.62,51.28 22.05,58.85 21.25,58.85 9.5,70.6 9.5,80.18 9.24,80.44 8.97,80.44 8.85,80.56 8.85,80.79 8.97,80.91 9.24,80.91 9.5,81.17 9.5,81.61 9.24,81.87 8.97,81.87 8.85,81.99 8.85,82.22 8.97,82.34 9.24,82.34 9.5,82.6 9.5,83.95 8.32,85.13 7.26,85.13 v1(6.97,85.42)
DSI1_DP2: length 55
  TOP w0.115: v1(33.56,53.34) 33.28,53.06 32.44,53.06 32.25,53.25 J1.112
  TOP w0.116: J12.12 5.67,88.25 5.8,88.13 6.67,88.13 v1(6.97,88.42)
  BOTTOM w0.116: v1(33.56,53.34) 33.14,53.34 32.87,53.07 29.73,53.07 22.2,60.6 21.2,60.6 10.7,71.1 10.7,86.25 8.83,88.13 7.26,88.13 v1(6.97,88.42)
DSI1_DP3: length 55
  TOP w0.115: v1(33.56,55.14) 33.28,54.86 32.44,54.86 32.25,55.05 J1.106
  TOP w0.116: v1(6.61,89.96) 6.27,89.63 5.8,89.63 5.67,89.75 J12.15
  BOTTOM w0.116: v1(33.56,55.14) 33.14,55.14 32.87,54.88 29.67,54.88 22.05,62.5 20.75,62.5 11.9,71.35 11.9,86.7 8.97,89.63 6.95,89.63 v1(6.61,89.96)
EMMC_DISABLE_N: length 137.6
  TOP w0.2: J1.2 33.15,89.85 35.7,87.3 45.8,87.3 51.7,93.2 60.4,93.2 61.7,94.5 82.3,94.5 83.4,93.4 83.4,13.38 83.03,13 Q1.3
EMMC_EN_N_1V8: length 87.5
  TOP w0.2: 79.02,11 79.02,13.19 72.75,19.45 72.75,44.9 69.3,48.35 63.65,48.35 52.15,59.85 J1.90 ; 79.02,11 79.02,10 R10.2 ; 79.02,11 Q2.1
GPIO0: length 58.3
  TOP w0.2: J1.3 v1(24.28,89.55)
  BOTTOM w0.2: J5.1 76.95,91.55 63.55,91.55 61.65,93.45 45.7,93.45 42.65,90.4 25.13,90.4 v1(24.28,89.55)
GPIO0-27_VREF: length 43.4
  TOP w0.3: v1(24.28,78.75) J1.39 C13.1 20.8,78.75 ; J1.40 v1(29.72,78.45)
  TOP w1: R7.1 v1(53.65,96.5)
  PWRB w1: v1(53.65,96.5) 50.1,96.5 35.35,81.75 31.95,81.75 29.72,79.52 v1(29.72,78.45) 25.48,78.45 25.18,78.75 v1(24.28,78.75)
GPIO1: length 59.1
  TOP w0.2: J1.5 v1(24.8,88.95)
  BOTTOM w0.2: J5.3 76.94,89 63.95,89 60.05,92.9 46.75,92.9 43.15,89.3 28.8,89.3 28.45,88.95 v1(24.8,88.95)
GPIO2: length 60.3
  TOP w0.2: J1.9 v1(24.28,87.75)
  BOTTOM w0.2: v1(24.28,87.75) 27.95,87.75 29.1,88.9 45.2,88.9 48.7,92.4 55.85,92.4 61.8,86.45 76.93,86.45 J5.5
GPIO3: length 57.8
  TOP w0.2: J1.11 v1(24.8,87.15)
  BOTTOM w0.2: v1(24.8,87.15) 25.15,86.8 28,86.8 28.5,86.3 30.1,86.3 30.9,87.1 50.7,87.1 51.6,86.2 58.6,86.2 60.8,84 77.02,84 J5.7
GPIO4: length 58.4
  TOP w0.2: J1.15 v1(25.2,85.95)
  BOTTOM w0.2: v1(25.2,85.95) 30.85,85.95 31.65,86.75 49.75,86.75 50.95,85.55 57.85,85.55 62,81.4 76.96,81.4 J5.9
GPIO5: length 59.3
  TOP w0.2: J1.17 v1(24.65,85.35)
  BOTTOM w0.2: J5.11 76.95,78.85 63.15,78.85 57.1,84.9 34.7,84.9 34.2,84.4 33.4,84.4 32.5,85.3 32,85.3 31.6,84.9 25.9,84.9 25.45,85.35 v1(24.65,85.35)
GPIO6: length 59.5
  TOP w0.2: J1.21 v1(25.3,84.15)
  BOTTOM w0.2: v1(25.3,84.15) 28.25,84.15 28.6,84.5 31.4,84.5 32.1,83.8 55.6,83.8 55.67,83.88 63.3,76.25 76.89,76.25 J5.13
GPIO7: length 60.5
  TOP w0.2: J1.23 v1(24.7,83.55)
  BOTTOM w0.2: J5.15 76.98,73.8 63.7,73.8 54.29,83.21 31.81,83.21 31.1,82.5 25.75,82.5 v1(24.7,83.55)
GPIO8: length 60.5
  TOP w0.2: J1.27 v1(25.05,82.35)
  BOTTOM w0.2: J5.17 76.92,71.2 63.9,71.2 53.2,81.9 25.5,81.9 v1(25.05,82.35)
GPIO9: length 61.3
  TOP w0.2: J1.29 v1(24.45,81.75)
  BOTTOM w0.2: J5.19 76.96,68.7 63.9,68.7 51.2,81.4 24.8,81.4 v1(24.45,81.75)
GPIO10: length 61.8
  TOP w0.2: J1.33 v1(25.05,80.55)
  BOTTOM w0.2: J5.21 77,66.2 64.05,66.2 50.04,80.21 25.39,80.21 v1(25.05,80.55)
GPIO11: length 62.6
  TOP w0.2: J1.35 v1(24.28,79.95)
  BOTTOM w0.2: v1(24.28,79.95) 24.61,79.61 48.14,79.61 64.1,63.65 76.99,63.65 J5.23
GPIO12: length 60.9
  TOP w0.2: J1.45 v1(24.95,73.35)
  BOTTOM w0.2: J5.25 76.98,61.1 63.85,61.1 52.05,72.9 25.4,72.9 v1(24.95,73.35)
GPIO13: length 61.7
  TOP w0.2: J1.47 v1(24.45,72.75)
  BOTTOM w0.2: v1(24.45,72.75) 24.85,72.35 49.5,72.35 63.25,58.6 77.02,58.6 J5.27
GPIO14: length 62.3
  TOP w0.2: J1.51 v1(25.05,71.55)
  BOTTOM w0.2: J5.29 76.96,56 63.75,56 48.55,71.2 25.4,71.2 v1(25.05,71.55)
GPIO15: length 63.1
  TOP w0.2: J1.53 v1(24.45,70.95)
  BOTTOM w0.2: J5.31 77,53.5 63.7,53.5 46.6,70.6 24.8,70.6 v1(24.45,70.95)
GPIO16: length 63.6
  TOP w0.2: J1.57 v1(25,69.75)
  BOTTOM w0.2: v1(25,69.75) 25.34,69.41 43.85,69.41 45.29,69.41 63.75,50.95 76.99,50.95 J5.33
GPIO17: length 64.4
  TOP w0.2: J1.59 v1(24.28,69.15)
  BOTTOM w0.2: v1(24.28,69.15) 24.61,68.81 43.29,68.81 63.7,48.4 76.98,48.4 J5.35
GPIO18: length 65
  TOP w0.2: J1.63 v1(25.05,67.95)
  BOTTOM w0.2: J5.37 76.92,45.8 63.45,45.8 41.64,67.61 25.39,67.61 v1(25.05,67.95)
GPIO19: length 65.8
  TOP w0.2: J1.65 v1(24.28,67.35)
  BOTTOM w0.2: v1(24.28,67.35) 24.61,67.01 39.79,67.01 63.5,43.3 76.96,43.3 J5.39
GPIO20: length 66.4
  TOP w0.2: J1.69 v1(24.85,66.15)
  BOTTOM w0.2: v1(24.85,66.15) 25.19,65.81 38.34,65.81 63.4,40.75 76.95,40.75 J5.41
GPIO21: length 67.2
  TOP w0.2: J1.71 v1(24.28,65.55)
  BOTTOM w0.2: J5.43 76.99,38.25 63.25,38.25 36.29,65.21 24.61,65.21 v1(24.28,65.55)
GPIO22: length 67.7
  TOP w0.2: J1.75 v1(26.25,64.35)
  BOTTOM w0.2: J5.45 77.03,35.75 63.85,35.75 35.59,64.01 26.59,64.01 v1(26.25,64.35)
GPIO23: length 69.5
  TOP w0.2: J1.77 v1(25.5,63.75)
  BOTTOM w0.2: v1(25.5,63.75) 25.84,63.41 35.09,63.41 62.42,36.08 62.42,34.53 63.85,33.1 76.92,33.1 J5.47
GPIO24: length 70.8
  TOP w0.2: J1.81 v1(28.9,62.55)
  BOTTOM w0.2: v1(28.9,62.55) 29.24,62.21 34.99,62.21 61.18,36.02 61.18,33.17 63.85,30.5 76.86,30.5 J5.49
GPIO25: length 72.4
  TOP w0.2: J1.83 v1(28.15,61.95)
  BOTTOM w0.2: v1(28.15,61.95) 28.49,61.61 34.49,61.61 60.14,35.96 60.14,31.76 63.95,27.95 76.85,27.95 J5.51
GPIO26: length 73.8
  TOP w0.2: J1.87 v1(28.35,60.75)
  BOTTOM w0.2: v1(28.35,60.75) 29.95,60.75 30.3,60.4 34.55,60.4 58.8,36.15 58.8,30.5 63.85,25.45 76.89,25.45 J5.53
GPIO27: length 75.2
  TOP w0.2: J1.89 v1(29.3,60.15)
  BOTTOM w0.2: v1(29.3,60.15) 29.64,59.81 33.94,59.81 57.95,35.8 57.95,29 63.95,23 76.98,23 J5.55
GPIO28: length 39.5
  TOP w0.2: 34.15,82.05 J1.28 ; 34.15,82.05 54.75,82.05 J6.1 ; 34.15,82.05 34.18,82.09 34.18,82.65 R27.1
GPIO28-45_VREF: length 43.6
  TOP w0.3: J1.42 v1(29.72,74.25) ; 20.8,74.55 C14.1 J1.41 v1(24.28,74.55)
  TOP w1: R8.1 v1(53.65,94.5)
  PWRB w1: v1(53.65,94.5) 49.97,94.5 v1(29.72,74.25) 29.42,74.55 v1(24.28,74.55)
GPIO29: length 38.7
  TOP w0.2: J6.3 56.69,81.45 34.15,81.45 ; R26.1 34.18,80.85 34.18,81.42 34.15,81.45 ; 34.15,81.45 J1.30
GPIO30: length 37.5
  TOP w0.2: J1.34 58.03,80.25 J6.5
GPIO31: length 36.7
  TOP w0.2: J6.7 59.97,79.65 J1.36
GPIO32: length 38.4
  TOP w0.2: J1.46 55.91,73.05 J6.9
GPIO33: length 37.6
  TOP w0.2: J1.48 57.85,72.45 J6.11
GPIO34: length 37.1
  TOP w0.2: J6.13 59.19,71.25 J1.52
GPIO35: length 36.3
  TOP w0.2: J6.15 61.13,70.65 J1.54
GPIO36: length 35.7
  TOP w0.2: J6.17 62.47,69.45 J1.58
GPIO37: length 34.9
  TOP w0.2: J1.60 64.41,68.85 J6.19
GPIO38: length 34.5
  TOP w0.2: J6.21 64.5,67.43 64.28,67.65 J1.64
GPIO39: length 35.3
  TOP w0.2: J6.23 63.37,67.05 J1.66
GPIO40: length 35.9
  TOP w0.2: J1.70 62.03,65.85 J6.25
GPIO41: length 36.7
  TOP w0.2: J6.27 60.09,65.25 J1.72
GPIO42: length 37.2
  TOP w0.2: J6.29 58.75,64.05 J1.76
GPIO43: length 38
  TOP w0.2: J1.78 56.81,63.45 J6.31
GPIO44: length 39.2
  TOP w0.2: 34.2,62.25 34.18,62.27 34.18,62.85 R29.1 ; 34.2,62.25 J1.82 ; 34.2,62.25 55.47,62.25 J6.33
GPIO45: length 40
  TOP w0.2: R28.1 37.47,61.64 37.45,61.65 ; 37.45,61.65 J1.84 ; 37.45,61.65 53.53,61.65 J6.35
H5V: length 20.9
  TOP w0.2: U4.A1 v1(13.42,55.1) ; v1(7.1,56.3) 7.3,56.5 J13.18 ; U4.C1 v1(13.42,55.9) ; Q3.1 v1(15.02,54)
  TOP w0.3: C16.1 16,58.51 15.34,58.51 14.75,57.93 U3.2 14.75,57.47 13.79,56.51 13.79,56.27 v1(13.42,55.9)
  PWRT w0.3: v1(7.1,56.3) 7.85,57.05 13.02,57.05 13.42,56.65 v1(13.42,55.9) v1(13.42,55.1) 13.42,54.43 13.85,54 v1(15.02,54)
  BOTTOM w0.5: PP10.1 15.02,52.52 v1(15.02,54)
HDMI_CEC: length 26.4
  TOP w0.2: J1.171 v1(20.6,35.55) ; v1(16.75,55) Q3.2 14.9,55 14.52,55.39 R15.1
  PWRT w0.2: v1(20.6,35.55) 20.6,47.55 16.75,51.4 v1(16.75,55)
HDMI_CK_N: length 13.5
  TOP w0.116: J1.111 21.73,53.55 21.55,53.38 19.97,53.38 19.72,53.13 11.94,53.13 11.56,53.5 J13.12
HDMI_CK_P: length 13.5
  TOP w0.116: J1.113 21.73,52.95 21.55,53.12 20.07,53.12 19.82,52.87 11.94,52.87 11.56,52.5 J13.10
HDMI_D0_N: length 13.3
  TOP w0.116: J1.117 21.73,51.75 21.71,51.74 11.83,51.74 11.56,52 J13.9
HDMI_D0_P: length 13.5
  TOP w0.116: J13.7 11.56,51 12.05,51.48 21.39,51.48 21.73,51.15 J1.119
HDMI_D1_N: length 13.5
  TOP w0.116: J1.123 21.73,49.95 21.55,49.78 20.17,49.78 19.82,50.13 11.94,50.13 11.56,50.5 J13.6
HDMI_D1_P: length 13.5
  TOP w0.116: J1.125 21.73,49.35 21.55,49.52 20.07,49.52 19.72,49.87 11.94,49.87 11.56,49.5 J13.4
HDMI_D2_N: length 13.7
  TOP w0.116: J1.129 21.73,48.15 21.55,47.98 19.82,47.98 19.17,48.63 11.94,48.63 11.56,49 J13.3
HDMI_D2_P: length 13.7
  TOP w0.116: J13.1 11.56,48 11.94,48.37 19.07,48.37 19.72,47.72 21.55,47.72 21.73,47.55 J1.131
HDMI_HPD: length 13.4
  TOP w0.2: Q4.1 6.8,62.5 5.9,61.6 5.9,58.3 7.2,57 J13.19 11.37,57 11.95,56.42 11.95,56.18 12.1,56.03 U4.C3
HDMI_HPD_N_1V8: length 31.3
  TOP w0.2: J1.88 33.45,60.45 v1(34,61) ; v1(11,60.85) R18.2 11,61.52 9.93,61.52 9.8,61.65 Q4.3
  PWRB w0.2: v1(34,61) 33.1,60.1 31,60.1 29.85,58.95 28.35,58.95 24.9,62.4 12.55,62.4 v1(11,60.85)
HDMI_SCL: length 35.2
  TOP w0.2: v1(7.55,54.8) 8.01,54.8 8.21,55 J13.15 11.27,55 11.37,55.1 U4.A3 ; J1.175 v1(20.6,34.35)
  PWRT w0.2: v1(7.55,54.8) 10.8,54.8 19,46.6 19,35.2 19.85,34.35 v1(20.6,34.35)
HDMI_SDA: length 35.2
  TOP w0.2: v1(7.55,55.5) J13.16 U4.B3 ; J1.173 v1(21.2,34.95)
  PWRT w0.2: v1(21.2,34.95) 20.15,34.95 19.75,35.35 19.75,46.95 11.2,55.5 v1(7.55,55.5)
RUN: length 148.7
  TOP w0.2: J1.177 v1(24.28,33.75) ; J7.1 32.55,99.15 32.9,98.8 v1(32.9,98.3)
  PWRT w0.2: v1(32.9,98.3) 39,92.2 39,33.6 37.4,32 35.4,32 33.65,33.75 v1(24.28,33.75)
  BOTTOM w0.2: v1(24.28,33.75) 25.33,34.8 36.8,34.8 37.8,33.8 52.8,33.8 57.15,29.45 57.15,27.2 63.9,20.45 76.97,20.45 J5.57
SDX_CLK: length 24.4
  TOP w0.15: J1.10 v1(29.3,87.45)
  TOP w0.2: 15.8,102.95 J16.5 15.8,102.95 ; 15.8,102.95 15.8,102.95 v1(15.8,102)
  PWRT w0.15: v1(15.8,102) 15.8,100.95 v1(29.3,87.45)
  BOTTOM w0.2: v1(15.8,102) PP15.1
SDX_CMD: length 26.2
  TOP w0.15: J1.12 v1(29,86.85)
  TOP w0.2: 13.6,102.95 13.59,102.95 13.6,102.95 ; 13.6,102.95 v1(13.6,102)
  PWRT w0.15: v1(13.6,102) 14.35,101.25 14.6,101.25 v1(29,86.85)
  BOTTOM w0.2: PP14.1 13.5,100.99 13.55,101.25 v1(13.6,102)
SDX_D0: length 27.9
  TOP w0.15: J1.16 v1(33,85.65)
  TOP w0.2: J16.7 18,102.95 v1(18,102)
  PWRT w0.15: v1(33,85.65) 33,86.8 28.4,91.4 28.4,92.7 22.95,98.15 22.43,98.15 21.89,98.7 21.3,98.7 v1(18,102)
  BOTTOM w0.2: v1(18,102) PP16.1
SDX_D1: length 29.7
  TOP w0.15: J1.18 v1(33.6,85.05)
  TOP w0.2: v1(19.05,102) 19.05,102.95 ; 19.05,102.95 J16.8 19.05,102.95
  PWRT w0.15: v1(33.6,85.05) 33.6,88.05 29.2,92.45 29.2,93.3 20.5,102 v1(19.05,102)
  BOTTOM w0.2: v1(19.05,102) PP17.1
SDX_D2: length 30.6
  TOP w0.15: J1.22 v1(29.2,83.85)
  TOP w0.2: v1(11.4,102) 11.4,102.95 ; 11.4,102.95 J16.1 11.4,102.95
  PWRT w0.15: v1(11.4,102) 13.2,100.2 13.78,100.2 22.39,91.6 23,91.6 29.2,85.4 v1(29.2,83.85)
  BOTTOM w0.2: v1(11.4,102) PP12.1
SDX_D3: length 30.2
  TOP w0.15: J1.24 v1(29.7,83.25)
  TOP w0.2: 12.5,102.95 J16.2 12.5,102.95 ; 12.5,102.95 v1(12.5,102)
  PWRT w0.15: v1(12.5,102) 13.7,100.8 14.29,100.8 29.7,85.38 v1(29.7,83.25)
  BOTTOM w0.2: v1(12.5,102) PP13.1
SDX_VREF: length 16.3
  TOP w0.3: J1.6 29.35,88.65 29,89 29.25,89.25 J1.4
  TOP w0.5: C23.1 24.35,97.95 24.35,96.1 R31.1
  TOP w1: R31.1 26,96 29,93 29,89
TVDAC: length 41.8
  TOP w0.125: J6.59 57.73,19.17 39.85,37.05 J1.166
USB_DM: length 18.3
  TOP w0.136: J1.167 24.08,36.75 24.25,36.92 24.88,36.92 25.37,36.43 25.37,36.14 25.24,36 25.14,36 25,35.87 25,35.6 25.14,35.46 25.24,35.46 25.37,35.32 25.37,22.02 25.3,21.95 U5.2
USB_DP: length 18.3
  TOP w0.136: J1.165 24.08,37.35 24.25,37.18 24.98,37.18 25.63,36.53 25.63,22.02 25.7,21.95 U5.1
USB_OTGID: length 46.2
  TOP w0.2: J1.168 38.75,36.45 v1(39.9,35.3) ; 63.25,24.25 v1(55.4,32.1) ; 63.25,24.25 61.68,22.68 R12.2 ; 63.25,24.25 J6.55
  BOTTOM w0.2: v1(55.4,32.1) 52.2,35.3 v1(39.9,35.3)
USBA_DM: length 10.4
  TOP w0.136: U5.6 25.3,19.71 25.37,19.64 25.37,18.07 28.37,15.07 28.37,12.37 J14.2
USBA_DP: length 10.4
  TOP w0.136: J14.3 28.63,12.37 28.63,15.17 25.63,18.17 25.63,19.64 25.7,19.71 U5.7
USBB_DM: length 25.1
  TOP w0.136: J15.2 13.35,4.82 13.35,5.88 13.55,6.08 13.55,17.15 17.13,20.73 24.14,20.73 24.21,20.8 U5.4
USBB_DP: length 25.1
  TOP w0.136: U5.5 24.21,20.4 24.14,20.47 23.85,20.47 23.71,20.34 23.71,20.34 23.58,20.2 23.31,20.2 23.17,20.34 23.17,20.34 23.03,20.47 22.76,20.47 22.63,20.34 22.63,20.34 22.49,20.2 22.22,20.2 22.08,20.34 22.08,20.34 21.95,20.47 17.23,20.47 13.8,17.05 13.8,6.08 14,5.88 J15.3
VC_TCK: length 74.6
  TOP w0.2: J7.8 v1(29.05,98.3) ; J1.180 v1(35.75,32.85)
  PWRT w0.2: v1(35.75,32.85) 35.75,90.35 29.05,97.05 v1(29.05,98.3)
VC_TDI: length 74.8
  TOP w0.2: J1.174 v1(37.9,34.65) ; J7.3 v1(31.55,98.3)
  PWRT w0.2: v1(31.55,98.3) 31.55,97.35 37.9,91 v1(37.9,34.65)
VC_TDO: length 75.4
  TOP w0.2: J1.178 v1(37.2,33.45) ; J7.5 v1(30.55,98.3)
  PWRT w0.2: v1(37.2,33.45) 37.2,90.75 30.55,97.4 v1(30.55,98.3)
VC_TMS: length 74.1
  TOP w0.2: J1.176 v1(36.4,34.05) ; v1(29.8,98) 29.8,98.5 30.05,98.75 J7.6
  PWRT w0.2: v1(29.8,98) 29.8,97.25 36.4,90.65 v1(36.4,34.05)
VC_TRST_N: length 74.8
  TOP w0.2: J1.172 v1(38.5,35.25) ; J7.2 32.05,99.15 32.2,99 v1(32.2,98.3)
  PWRT w0.2: v1(38.5,35.25) 38.5,91.3 32.2,97.6 v1(32.2,98.3)
VG0: length 27.3
  TOP w1: J3.3 67,102.7 66,103.7 63.48,103.7 56.45,96.67 R7.2
  PWRB w1: 83.5,29.33 J5.52 ; 83.5,59.5 83.5,59.81 J5.28 ; 83,75.05 J5.16 ; J3.3 67,103.4 ; 83.5,44.57 J5.40
VG1: length 27.8
  TOP w1: R8.2 57.6,94.5 59.9,96.8 66.23,96.8 67,97.57 J3.4
  PWRB w1: 70.93,44.57 J6.40 ; 70.83,29.33 J6.52 ; 70.95,75.05 J6.16 ; 71,59.5 70.69,59.81 J6.28 ; 67,96.5 J3.4
N1195355: length 5.3
  TOP w0.3: 47.8,5.42 R9.2 v1(47.8,3.3) D2.2
  BOTTOM w0.3: v1(47.8,3.3) 46.3,3.3 PP9.1
N1195439: length 56.2
  TOP w0.2: Q1.2 81.43,12.5 82.8,11.12 Q2.3 82.8,8.8 82.4,8.4 78.4,8.4 77.2,9.6 77.2,11.4 73.2,15.4 50.4,15.4 46.2,11.2 D2.1
N1202496: length 2.6
  TOP w0.2: C6.1 61.21,11.25 61.21,9.7 ; R2.2 61.21,9.7 ; 61.21,9.7 61.21,9.16 61.2,9.14 U1.12
N1202592: length 3.1
  TOP w0.25: U1.8 63.2,6.83 64,6.02 L1.1
N1202604: length 3.1
  TOP w0.25: L2.1 55,8.98 55.8,8.18 U1.2
N1202780: length 6
  TOP w0.4: F1.1 71.7,6.7 J2.1
  TOP w0.5: F1.1 v1(71,9)
  BOTTOM w0.5: v1(71,9) PP1.1
N1203166: length 1.4
  TOP w0.3: U2.4 42.1,11.82 C9.1
N1203318: length 7.6
  TOP w0.3: D1.2 v1(52.8,3.3) 50.68,5.42 R3.2
  BOTTOM w0.3: PP7.1 52.8,2.8 v1(52.8,3.3)
N1313759: length 3.6
  TOP w0.2: U1.4 56.95,7.27 56.94,7.28 R22.2 C21.2 R25.1
N1313939: length 3.6
  TOP w0.2: U1.10 62.05,7.73 62.06,7.72 62.6,7.72 ; 62.6,7.72 63.7,7.72 ; 62.6,7.72 R23.2 ; 63.7,7.72 C22.2 ; 63.7,7.72 64.8,7.72 R24.1
N1329395: length 32.3
  TOP w0.2: v1(10.9,7.42) Q5.3 10.48,8.2 10.18,8.5 R20.2 9.38,8.5 ; v1(27.3,21.65) 26.85,21.2 U5.10
  BOTTOM w0.2: PP11.1 10.38,8.12 10.38,7.94 v1(10.9,7.42) 12.5,9.02 12.5,15 20,22.5 26.45,22.5 v1(27.3,21.65)
N1357591: length 70.1
  TOP w0.2: R30.1 81.2,14.29 Q1.1 v1(80.2,13.5)
  BOTTOM w0.2: J4.2 21.2,17.2 48.5,17.2 50.9,14.8 78.9,14.8 v1(80.2,13.5)

## Copper pours and planes (outline as drawn)
1V8 on PWRT (solid shape): outline of 23645 points within 0.5,10.85 84.5,104.5
3V3 on PWRB (solid shape): outline of 29477 points within 0.5,0.5 84.5,104.5
5V on PWRT (solid shape): outline of 8962 points within 0.5,0.5 84.5,94.1
GND on TOP (solid shape): 60.5,8.8 60.4,8.8 60.4,6.2 60.15,6.2 60.15,2.25 58.5,2.25 58.5,5.75 58.6,5.75 58.6,8.8 58.85,8.8 58.85,13.3 60.5,13.3
GND on TOP (solid shape): outline of 17441 points within 0.5,0.5 84.5,104.5
GND on BOTTOM (solid shape): 50.27,85.87 50.29,85.76 50.2,85.7 33.4,85.7 33.39,85.74 33,86.05 32.61,85.74 32.6,85.7 31.2,85.7 31.11,85.76 31.13,85.87 31.75,86.5 49.65,86.5
GND on BOTTOM (solid shape): 63.6,73.55 64.95,73.55 65.05,73.48 65.01,73.36 64.53,72.49 65.04,71.64 65.08,71.53 64.99,71.45 64,71.45 53.3,82.15 31.35,82.15 31.26,82.21 31.28,82.32 31.92,82.96 54.18,82.96
GND on BOTTOM (solid shape): 45.2,88.55 44.23,87.57 44.2,87.53 44.2,87.48 44.18,87.39 44.1,87.35 30.8,87.35 30,86.55 29.46,86.55 29.38,86.6 29.37,86.69 29.4,86.82 29.39,86.96 29.39,87.03 29.45,87.08 29.48,87.81 28.91,87.34 28.91,87.27 28.85,87.22 28.66,87.06 28.6,86.81 28.54,86.7 28.43,86.72 28.11,87.05 25.26,87.05 25.2,87.11 25.2,87.13 25.19,87.24 25.15,87.35 25.15,87.45 25.24,87.5 28.05,87.5 29.2,88.65 45.1,88.65
GND on BOTTOM (solid shape): 24.32,65.15 24.51,64.96 36.18,64.96 63.15,38 64.97,38 65.07,37.93 65.02,37.81 64.53,37.03 64.89,36.18 64.92,36.07 64.83,36 63.95,36 35.69,64.26 26.69,64.26 26.65,64.3 26.65,64.35 25.97,64.63 26.25,63.95 26.3,63.95 26.41,63.84 26.43,63.73 26.34,63.66 25.94,63.66 25.9,63.7 25.9,63.75 25.67,64.11 25.25,64.06 25.21,64.03 24.14,65.1 24.2,65.16
GND on BOTTOM (solid shape): outline of 16890 points within 0.5,0.5 84.5,104.5
GND on GNDT (solid shape): outline of 20665 points within 0.5,0.5 84.5,104.5
GND on GNDB (solid shape): outline of 20665 points within 0.5,0.5 84.5,104.5
CM_1V8 on PWRB (solid shape): 32.09,32.16 32.48,31.85 32.87,32.16 32.88,32.2 36.3,32.2 40.3,28.2 40.3,20.6 37.2,20.6 37.2,27.4 33.8,30.8 29.92,30.8 29.91,30.81 29.72,30.85 29.54,30.81 29.53,30.8 24.68,30.8 24.67,30.84 24.28,31.15 23.89,30.84 23.88,30.8 21.3,30.8 21.3,32.06 21.34,32.14 21.43,32.16 21.57,32.15 21.71,32.19 21.72,32.2 32.08,32.2
CM_3V3 on PWRB (solid shape): 24.9,29.5 31.8,29.5 32.3,29.4 33.4,29.4 35.7,27.1 35.7,20.6 33,20.6 33,28.1 32.7,28.4 29.92,28.4 29.91,28.41 29.72,28.45 29.54,28.41 29.53,28.4 24.68,28.4 24.67,28.44 24.28,28.75 23.89,28.44 23.88,28.4 21.3,28.4 21.3,29.66 21.34,29.74 21.43,29.76 21.57,29.75 21.71,29.79 21.72,29.8 24.6,29.8
CM_VBAT on PWRB (solid shape): 24.09,27.99 24.28,27.95 24.46,27.99 24.47,28 29.32,28 29.33,27.96 29.72,27.65 30.11,27.96 30.12,28 32.7,28 32.7,20.6 30.1,20.6 30.1,26.6 21.3,26.6 21.3,28 24.08,28
VG0 on PWRB (solid shape): outline of 1280 points within 66,28.5 84.5,104.5
VG1 on PWRB (solid shape): 72,97 72,29 71.5,28.5 70.5,28.5 70,29 70,95 69.5,95.5 66.5,95.5 66,96 66,97 66.5,97.5 71.5,97.5

Small or netless copper shapes (teardrops, artwork): 4 on TOP, 14 on BOTTOM

## Text on the board
BOTTOM: L06 - BOTTOM
Ref Des/Silkscreen Bottom: BOTTOM COMPONENT LEGEND
User.Comments: TOP SOLDER MASK | BOTTOM SOLDER MASK
TOP: L01 - TOP
Package Geometry/Pastemask Top: TOP PASTE MASK
Ref Des/Silkscreen Top: GND | 5V0 | 3V3 | 1V8 | VG1 | NC | VG0 | EN | USB SLAVE | DIS | BOOT ENABLE | USB_ | CD1_SDA | CD1_SCL | CAM1_IO1 | CAM1_IO0 | CD0_SDA | CD0_SCL | CAM0_IO1 | CAM0_IO0 | 28 | 29 | 30 | 31 | 32 | 33 | 34 | 35 | 36 | 37 | 38 | 39 | 40 | 41 | 42 | 43 | 44 | 45 | VDD_CORE | TVDAC | OTGID | 0 | 1 | 2 | 3 | 4 | 5 | 6 | 7 | 8 | 9 | 10 | 11 | 12 | 13 | 14 | 15 | 16 | 17 | 18 | 19 | 20 | 21 | 22 | 23 | 24 | 25 | 26 | 27 | RUN | VG0 SELCT | VG1 SELCT | GPIOx BANK 1 | GPIOx BANK 0 | SD CARD ONLY FOR | MODULES WITHOUT | ON-BOARD FLASH | VC JTAG | ACT | Made in the UK | Compute Module IO Board V3.0 | (c) Raspberry Pi 2014/15 | PWR | USB HOST | POWER IN | DISP1 | TOP COMPONENT LEGEND | DISP0 | CAM1 | CAM0 | RASPBERRY PI COMPUTE MODULE | OR COMPUTE MODULE 3
GNDT: L02 - GND
PWRT: L03 - PWR/ROUTING
PWRB: L04 - PWR/ROUTING
GNDB: L05 - GND
DIMENSION: LAYER | L1 TOP/SIG | L2 GND | L3 PWR/SIG | L4 PWR/SIG | L5 GND | L6 BOTTOM/SIG | TOP PASTE MASK | TOP COMPONENT LEGEND | TOP SOLDER MASK | BOTTOM SOLDER MASK | BOTTOM COMPONENT LEGEND | BOTTOM PASTE MASK | DRILL DWG/MECHANICAL | BOARD OUTLINE/EDGES | PLATED DRILL (LAYER X TO Y) | NON-PLATED DRILL | PLATED ROUTE | NON-PLATED ROUTE | DIELECTRIC | um | 18 | 115 | 355 | DETAILS | PLATED TO 33.4 um MIN | CU 1/2 OZ | PREPREG | CORE | PREPREG TO SUIT OVERALL THICKNESS | WHITE | GREEN | NONE | FORMAT: 3.3 / ABS / METRIC | DATA REF | *-TPM.art | *-TCL.art | *-TSM.art | *-BSM.art | *-DRM.art | *-BRD.art | *-X-Y.drl | *-X-Y-np.drl | *-X-Y.rou | *-L01.art | *-L02.art | *-L03.art | *-L04.art | *-L05.art | *-L06.art | BOARD THICKNESS | BOARD FLATNESS | PTH WALL THICKNESS | HOLES (EXCL. VIAS) | VIAS | FINISH | SOLDER RESIST | LEGEND | MANUFACTURING CODES | UL REQUIREMENTS | IMPEDANCE | TYPE | LAYER(S) | REF. PLANE(S) | TRACE WID | TRACE GAP | TOLERANCE | 90R | EC MICSTP | L1 | L2 | 136u | 115u | +/- 10% | 1.6mm +/- 10% | 1% DEVIATION FROM MAX DIMENSION | 18um COPPER MINIMUM | ALL PLATED HOLES TO +/- 0.1mm | ALL NON-PLATED HOLES TO +/- 0.05mm | FINISHED HOLE SIZE NOT CRITICAL | CHOOSE DRILL SIZE FOR BEST YIELD | NICKEL/GOLD (ENIG) | GREEN LIQUID-IMAGED (BOTH SIDES) | WHITE PHOTO-IMAGED | ADD MANUF. CODES WHERE INDICATED | BOARD TO BE MANUFACTURED TO UL94-V0 | 100R | 116u | 135u | L6 | L5 | DRILL DWG / MECHANICAL | (ON TOP SIDE) | ADD MANUFACTURING CODES HERE | ROUTE TOP AND BOTTOM (SHORT) EDGES | V-SCORE LEFT AND RIGHT (LONG) EDGES | BOARD PANELISATION: | CONTROLLED IMPEDANCE DATA | 85 | 105 | LAYER DETAILS - BOARD STACKUP | LAYER DETAILS - OTHER | MANUFACTURING DETAILS
TITLEBLOCK: TITLE | DRAWN | DATE | c  Raspberry Pi 2015 | APVD | REF | www.raspberrypi.org | 16/09/2015 | James Adams | RASPBERRY PI COMPUTE MODULE IO BOARD | RPI-CMIO V3.0
NCLEGEND-1-6: FIGURE | SIZE | 0.25 | 1.0 | 2.3 | 1.1 | 1.6 | 2.4 | 3.4 | 1.05x0.65 | 1.4x0.7 | 1.7x0.9 | 2.7x0.9 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILLIMETERS | PLATED | NON-PLATED | QTY | 476 | 133 | 2 | 1 | 4
